# IAR project RTX_ex1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\INC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTX_ex1.srec
  ILINK.IlinkOutputFile: RTX_ex1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group RTX Configuration
    ../: RTX_Conf_CM.c
  group RTX Library
    ../../../LIB/IAR/: RTX_CM3.a
  group Source Files
    ../: RTX_ex1.c
  group Startup
    ./: startup_ARMCM3.s
    ../: system_ARMCM3.c
