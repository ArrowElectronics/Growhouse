# IAR project Example1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\INC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Example1.srec
  ILINK.IlinkOutputFile: Example1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group RTX Configuration
    ../: RTX_Conf_CM.c
  group RTX Library
    ../../../../LIB/IAR/: RTX_CM3.a
  group Source Files
    ../: main.cpp Serial.c
    ./: Retarget.c
  group Startup
    ./: startup_ARMCM3.s
    ../: system_ARMCM3.c
