# IAR project Traffic.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\INC
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Traffic.srec
  ILINK.IlinkOutputFile: Traffic.out
  ILINK.IlinkIcfFile: LPC17xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Documentation
    ../: Abstract.txt
  group RTX Configuration
    ../: RTX_Conf_CM.c
  group RTX Library
    ../../../../../LIB/IAR/: RTX_CM3.a
  group Source Files
    ../: Getline.c GLCD_SPI_LPC1700.c KBD.c LED.c Serial.c Traffic.c
    ./: Retarget.c
  group StartUp
    ./: startup_LPC17xx.s
    ../: system_LPC17xx.c
