# IAR project ncp-uart-sw.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG13P632F512GM48 SiliconLaboratories EFR32MG13P632F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STA_GECKO_INFO_PAGE_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG3_MICRO; EFR32MG13P; EFR32MG13P632F512GM48; CONFIGURATION_HEADER="ncp-configuration.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; EMBER_AF_NCP; EMBER_STACK_ZIGBEE; USE_SIMEE2; EZSP_UART; NO_USB; EMBER_PARAMETERIZED_BROADCAST_TABLE; EMLIB_USER_CONFIG; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=32; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL1_XONXOFF; APPLICATION_TOKEN_HEADER="ncp-token.h"; APPLICATION_MFG_TOKEN_HEADER="ncp-mfg-token.h"; PHY_RAIL=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee\app\ncp; ..\..\..\protocol\zigbee\app\ncp\..\..; ..\..\..\protocol\zigbee\app\ncp\..\..\stack; ..\..\..\protocol\zigbee\app\ncp\..\util; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs-Restricted\efr32mg13p\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg13p\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\plugin; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\platform\halconfig\inc\hal-config; ..\..\..\hardware\kit\common\halconfig; ..\..\..\hardware\kit\common\bsp; hal-config; ..\..\..\platform\bootloader; ..\..\..\platform\radio\rail_lib\chip\efr32; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\protocol\ieee802154
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STA_GECKO_INFO_PAGE_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; EFR32_SERIES1_CONFIG3_MICRO; EFR32MG13P; EFR32MG13P632F512GM48; CONFIGURATION_HEADER="ncp-configuration.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; EMBER_AF_NCP; EMBER_STACK_ZIGBEE; USE_SIMEE2; EZSP_UART; NO_USB; EMBER_PARAMETERIZED_BROADCAST_TABLE; EMLIB_USER_CONFIG; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=32; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL1_XONXOFF; APPLICATION_TOKEN_HEADER="ncp-token.h"; APPLICATION_MFG_TOKEN_HEADER="ncp-mfg-token.h"; PHY_RAIL=1
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee\app\ncp; ..\..\..\protocol\zigbee\app\ncp\..\..; ..\..\..\protocol\zigbee\app\ncp\..\..\stack; ..\..\..\protocol\zigbee\app\ncp\..\util; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs-Restricted\efr32mg13p\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg13p\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\platform\halconfig\inc\hal-config; ..\..\..\hardware\kit\common\halconfig; ..\..\..\hardware\kit\common\bsp; hal-config; ..\..\..\platform\bootloader; ..\..\..\platform\radio\rail_lib\chip\efr32; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\protocol\ieee802154
  OBJCOPY.OOCOutputFile: ncp-uart-sw.s37
  prebuild: ncp-uart-sw-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  postbuild: ncp-uart-sw-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  ILINK.IlinkOutputFile: ncp-uart-sw.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=524288; RAM_SIZE=65536; SIMEEPROM_SIZE=36864; STA_GECKO_INFO_PAGE_BTL=1
  ILINK.IlinkIcfFile: C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\growhouse\end-devices\gecko_sdk_suite\v2.3\platform\base\hal/micro/cortexm3/efm32/iar-cfg.icf
  group emdrv
    ../../../platform/base/hal/../../emdrv/dmadrv/src/: dmadrv.c
    ../../../platform/base/hal/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../platform/base/hal/../../emdrv/rtcdrv/src/: rtcdriver.c
    ../../../platform/base/hal/../../emdrv/sleep/src/: sleep.c
    ../../../platform/base/hal/../../emdrv/tempdrv/src/: tempdrv.c
    ../../../platform/base/hal/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../platform/base/hal/../../emlib/src/: em_adc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_i2c.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../platform/base/hal/../../Device/SiliconLabs/EFR32MG13P/Source/: system_efr32mg13p.c
  group adc
    ../../../platform/base/hal/plugin/adc/: adc-efr32.c
  group antenna-stub
    ../../../platform/base/hal/plugin/antenna-stub/: antenna-stub.c
  group button-stub
    ../../../platform/base/hal/micro/generic/: button-stub.c
  group buzzer-stub
    ../../../platform/base/hal/plugin/buzzer-stub/: buzzer-stub.c
  group coexistence
    ../../../platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154/: coexistence-802154.c
    ../../../platform/radio/rail_lib/plugin/coexistence/common/: coexistence.c
    ../../../platform/radio/rail_lib/plugin/coexistence/hal/efr32/: coexistence-hal.c
  group debug-basic-library
    ../../../platform/base/hal/plugin/debug/rtt/: SEGGER_RTT.c
  group debug-channel
    ../../../platform/base/hal/plugin/debug-jtag/: debug-jtag-efr32.c
  group diagnostic
    ../../../platform/base/hal/micro/cortexm3/efm32/: diagnostic.c
  group ember-minimal-printf
    ../../../platform/base/hal/plugin/serial/: ember-printf.c
  group hal-library
    ../../../platform/base/hal/micro/cortexm3/efm32/: assert-crash-handlers.c cstartup-common.c faults-v7m.s79 hal-config.c hal-config-gpio.c isr-stubs.s79 mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c
    ../../../platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
  group led
    ../../../platform/base/hal/micro/cortexm3/efm32/: led.c
  group ncp-uart
    ../../../protocol/zigbee/app/em260/: em260-common.c serial-interface-uart.c
    ../../../protocol/zigbee/stack/config/: ember-configuration.c
  group secure-ezsp-stub
    ../../../protocol/zigbee/app/util/ezsp/: secure-ezsp-stub.c
    ../../../protocol/zigbee/app/em260/: command-handlers-secure-ezsp-stub.c
  group serial
    ../../../platform/base/hal/plugin/serial/: serial.c
  group sim-eeprom2
    ../../../platform/base/hal/plugin/sim-eeprom2/: sim-eeprom2.c
  group Generated
    ./: ncp-bookkeeping.c ncp-events.c ezsp-command-handler.c ncp-callback-stubs.c ncp-callbacks.c
  group Additional
    ../../../platform/base/hal/micro/cortexm3/efm32/: bootloader-interface.c bootloader-interface-standalone.c
    ../../../platform/bootloader/api/: btl_interface.c
    ./: ezsp-command-handler.c
    ../../../platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../../platform/emdrv/uartdrv/src/: uartdrv.c
  group Libraries
    ../../../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg13_iar_release.a
    ../../../protocol/zigbee/build/binding-table-library-cortexm3-iar-efr32mg13p-rail/: binding-table-library.a
    ../../../protocol/zigbee/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg13p-rail/: cbke-163k1-stub-library.a
    ../../../protocol/zigbee/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg13p-rail/: cbke-283k1-stub-library.a
    ../../../protocol/zigbee/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg13p-rail/: cbke-library-dsa-sign-stub.a
    ../../../protocol/zigbee/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg13p-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../../protocol/zigbee/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg13p-rail/: cbke-library-dsa-verify-stub.a
    ../../../protocol/zigbee/build/cbke-stub-library-cortexm3-iar-efr32mg13p-rail/: cbke-stub-library.a
    ../../../protocol/zigbee/build/debug-basic-library-cortexm3-iar-efr32mg13p-rail/: debug-basic-library.a
    ../../../protocol/zigbee/build/debug-extended-library-cortexm3-iar-efr32mg13p-rail/: debug-extended-library.a
    ../../../protocol/zigbee/build/em260-concentrator-library-cortexm3-iar-efr32mg13p-rail/: em260-concentrator-library.a
    ../../../protocol/zigbee/build/em260-uart-util-library-cortexm3-iar-efr32mg13p-rail/: em260-uart-util-library.a
    ../../../protocol/zigbee/build/em260-xncp-stub-library-cortexm3-iar-efr32mg13p-rail/: em260-xncp-stub-library.a
    ../../../protocol/zigbee/build/end-device-bind-library-cortexm3-iar-efr32mg13p-rail/: end-device-bind-library.a
    ../../../protocol/zigbee/build/gp-library-cortexm3-iar-efr32mg13p-rail/: gp-library.a
    ../../../protocol/zigbee/build/hal-library-cortexm3-iar-efr32mg13p-rail/: hal-library.a
    ../../../protocol/zigbee/build/install-code-library-cortexm3-iar-efr32mg13p-rail/: install-code-library.a
    ../../../protocol/zigbee/build/mfglib-library-cortexm3-iar-efr32mg13p-rail/: mfglib-library.a
    ../../../protocol/zigbee/build/multi-network-library-cortexm3-iar-efr32mg13p-rail/: multi-network-library.a
    ../../../protocol/zigbee/build/ncp-ash-fifo-xon-xoff-library-cortexm3-iar-efr32mg13p-rail/: ncp-ash-fifo-xon-xoff-library.a
    ../../../protocol/zigbee/build/ncp-binding-library-cortexm3-iar-efr32mg13p-rail/: ncp-binding-library.a
    ../../../protocol/zigbee/build/ncp-cbke-library-cortexm3-iar-efr32mg13p-rail/: ncp-cbke-library.a
    ../../../protocol/zigbee/build/ncp-gp-library-cortexm3-iar-efr32mg13p-rail/: ncp-gp-library.a
    ../../../protocol/zigbee/build/ncp-mfglib-library-cortexm3-iar-efr32mg13p-rail/: ncp-mfglib-library.a
    ../../../protocol/zigbee/build/ncp-pro-library-cortexm3-iar-efr32mg13p-rail/: ncp-pro-library.a
    ../../../protocol/zigbee/build/ncp-security-library-cortexm3-iar-efr32mg13p-rail/: ncp-security-library.a
    ../../../protocol/zigbee/build/ncp-zll-library-cortexm3-iar-efr32mg13p-rail/: ncp-zll-library.a
    ../../../protocol/zigbee/build/packet-validate-library-cortexm3-iar-efr32mg13p-rail/: packet-validate-library.a
    ../../../protocol/zigbee/build/security-library-core-cortexm3-iar-efr32mg13p-rail/: security-library-core.a
    ../../../protocol/zigbee/build/security-library-link-keys-cortexm3-iar-efr32mg13p-rail/: security-library-link-keys.a
    ../../../protocol/zigbee/build/sim-eeprom2-1to2-upgrade-stub-library-cortexm3-iar-efr32mg13p-rail/: sim-eeprom2-1to2-upgrade-stub-library.a
    ../../../protocol/zigbee/build/sim-eeprom2-library-cortexm3-iar-efr32mg13p-rail/: sim-eeprom2-library.a
    ../../../protocol/zigbee/build/zigbee-pro-stack-cortexm3-iar-efr32mg13p-rail/: zigbee-pro-stack.a
    ../../../protocol/zigbee/build/zigbee-r22-support-stub-library-cortexm3-iar-efr32mg13p-rail/: zigbee-r22-support-stub-library.a
    ../../../protocol/zigbee/build/zll-library-cortexm3-iar-efr32mg13p-rail/: zll-library.a
