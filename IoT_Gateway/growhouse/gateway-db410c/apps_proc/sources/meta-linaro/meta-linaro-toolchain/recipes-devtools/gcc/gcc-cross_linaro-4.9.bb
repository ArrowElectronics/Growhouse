BASEPV = "4.9"
PV = "linaro-${BASEPV}"
require recipes-devtools/gcc/gcc-${PV}.inc
require recipes-devtools/gcc/gcc-cross.inc
