require gcc-linaro-common-4.9.inc
require recipes-devtools/gcc/gcc-cross_${PV}.bb
require recipes-devtools/gcc/gcc-crosssdk.inc
