require gcc-linaro-common-5.2.inc
require gcc-linaro-5.2.inc
require recipes-devtools/gcc/libgfortran.inc

