PR = "r5.1"
FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
