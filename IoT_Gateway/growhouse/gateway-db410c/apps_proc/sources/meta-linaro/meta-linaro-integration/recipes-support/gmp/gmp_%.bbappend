FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-configure.ac-add-build-options-for-ilp32.patch"
