FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-arm64-ILP32-support-to-nspr-config.patch"
