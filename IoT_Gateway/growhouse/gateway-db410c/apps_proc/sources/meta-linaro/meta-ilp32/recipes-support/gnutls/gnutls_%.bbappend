FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-disable-acceleration-as-we-are-building-for-ilp32.patch"
