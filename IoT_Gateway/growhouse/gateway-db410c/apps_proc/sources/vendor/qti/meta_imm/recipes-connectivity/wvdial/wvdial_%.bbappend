PNBLACKLIST[wvdial] = ""
