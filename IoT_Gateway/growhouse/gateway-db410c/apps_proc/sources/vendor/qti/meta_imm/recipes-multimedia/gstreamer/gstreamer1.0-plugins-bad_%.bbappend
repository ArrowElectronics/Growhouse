PACKAGECONFIG_append = " egl gles2"
