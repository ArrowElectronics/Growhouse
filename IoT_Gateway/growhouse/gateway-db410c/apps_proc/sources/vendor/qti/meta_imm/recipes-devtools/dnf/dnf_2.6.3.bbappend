FILESEXTRAPATHS_prepend := "${THISDIR}/dnf:"

SRC_URI += "\
    file://0001-Solve-issue-with-RPM-disk-space-calculation.patch \
    "


