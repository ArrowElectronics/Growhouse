PACKAGECONFIG_remove = "vdpau"
