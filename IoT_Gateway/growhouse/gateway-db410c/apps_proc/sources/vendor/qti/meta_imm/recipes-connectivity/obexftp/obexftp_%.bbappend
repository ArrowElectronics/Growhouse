# The obexftp blacklist is obsolete and can be safely disabled.
PNBLACKLIST[obexftp] = ""
