TARGET_CFLAGS_append = " -O0"
TARGET_CXXFLAGS_append = " -O0"
PNBLACKLIST[wvstreams] = ""
