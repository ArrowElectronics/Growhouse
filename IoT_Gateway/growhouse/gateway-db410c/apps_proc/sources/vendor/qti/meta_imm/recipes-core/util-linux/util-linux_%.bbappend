RRECOMMENDS_${PN} += "util-linux-lscpu"
