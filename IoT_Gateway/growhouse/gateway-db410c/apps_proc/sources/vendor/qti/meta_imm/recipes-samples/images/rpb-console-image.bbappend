CORE_IMAGE_BASE_INSTALL += " \
    openjdk-8 \
    mosquitto \
    dbus-java-rootfs \
    unixsocket-java-rootfs \
    minicom \
    rsyslog \
    cronie \
"
