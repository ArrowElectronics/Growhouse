RDEPENDS_packagegroup-rpb += " \
    alsa-utils \
    bc \
    binutils \
    bluez5-noinst-tools \
    dhcp-client \
    dhcp-relay \
    dhcp-server \
    diag \
    evtest \
    expect \
    faac \
    fio \
    gcc \
    ifupdown \
    iozone3 \
    iperf3 \
    iproute2 \
    lame \
    lmbench \
    make \
    modemmanager \
    obexd \
    obexftp \
    phoronix-test-suite \
    pulseaudio \
    pulseaudio-module-bluetooth-discover \
    pulseaudio-module-bluetooth-policy \
    pulseaudio-module-bluez5-device \
    pulseaudio-module-bluez5-discover \
    pulseaudio-server \
    python-cmd2 \
    python-pygps \
    rpmsgexport \
    setserial \
    tcpdump \
    usb-modeswitch \
    util-linux \
    v4l-utils \
    x220d-modem-config \
    python-pexpect \
    python-pyyaml \
    dhrystone \
    cpufrequtils \
    spitools \
    sysbench \
    flac \
    i2c-tools \
    python-pip \
    adsprpc \
"
