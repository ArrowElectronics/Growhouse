PACKAGECONFIG_append = " modemmanager ppp"
