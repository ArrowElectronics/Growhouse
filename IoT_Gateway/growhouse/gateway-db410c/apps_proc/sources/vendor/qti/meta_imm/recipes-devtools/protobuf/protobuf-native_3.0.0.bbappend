SRC_URI[md5sum] = "41f2934b451a82115ccc4aa1f9b156f2"
SRC_URI[sha256sum] = "44e36eee53a7bc8b88935b105c8e2773f6ae9f89e3f25e95f93c4bcac908bb98"
