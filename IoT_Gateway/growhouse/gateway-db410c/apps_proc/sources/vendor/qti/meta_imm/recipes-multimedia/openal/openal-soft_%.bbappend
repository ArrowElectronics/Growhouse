EXTRA_OECMAKE = "-DINSTALL_LIB_DIR:PATH=${baselib}"
FILES_${PN} += "${libdir}"
