CORE_IMAGE_BASE_INSTALL += " zigbee-coordinator "
