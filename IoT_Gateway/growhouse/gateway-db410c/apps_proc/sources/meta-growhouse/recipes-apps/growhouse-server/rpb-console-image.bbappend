CORE_IMAGE_BASE_INSTALL += " growhouse-server "
