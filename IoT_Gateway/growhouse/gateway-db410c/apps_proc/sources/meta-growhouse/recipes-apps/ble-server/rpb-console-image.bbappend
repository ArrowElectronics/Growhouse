CORE_IMAGE_BASE_INSTALL += " ble-server "
