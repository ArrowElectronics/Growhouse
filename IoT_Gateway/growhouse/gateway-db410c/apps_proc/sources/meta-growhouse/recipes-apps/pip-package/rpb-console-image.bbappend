CORE_IMAGE_BASE_INSTALL += " pip-package "
