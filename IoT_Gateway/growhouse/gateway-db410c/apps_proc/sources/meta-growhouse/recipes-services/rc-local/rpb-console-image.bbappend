CORE_IMAGE_BASE_INSTALL += " rc-local "
