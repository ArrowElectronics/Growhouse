RDEPENDS_packagegroup-rpb-tests-x11_append = " gst-validate xserver-xorg-xvfb"
