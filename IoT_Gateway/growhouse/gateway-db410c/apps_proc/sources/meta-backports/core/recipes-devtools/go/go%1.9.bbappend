SRC_URI_remove = "file://default-buildmode-pie.patch"
