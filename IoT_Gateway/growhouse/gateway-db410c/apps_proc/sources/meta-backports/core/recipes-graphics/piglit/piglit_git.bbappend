FILESEXTRAPATHS_append := "${THISDIR}/${PN}"

SRC_URI += "file://0001-tests-egl-egl-context-priority.c-Use-piglit_egl_get_.patch"
