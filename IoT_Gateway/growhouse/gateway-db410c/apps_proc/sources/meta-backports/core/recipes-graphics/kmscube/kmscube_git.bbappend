FILESEXTRAPATHS_append := "${THISDIR}/${PN}"

SRC_URI += "file://detect-gst_bo_map-_unmap-and-use-it-or-avoid-it.patch"
